options:
  parameters:
    author: Leocarlos B S Lima/Edson P da Silva
    category: Custom
    description: Experimento para Laboratório de Princípios de Comunicações. Departamento de Engenharia Elétrica - DEE da Universidade Federal de Campina Grande - UFCG.
    generate_options: qt_gui
    id: Labo2_3
    output_language: python
    title: Relacao sinal-ruido de sinal de audio
  states: {}

blocks:
- name: ar
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Amplitude do Ruido
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequencia de Corte
    outputmsgname: value
    showports: 'False'
    start: '100'
    step: '100'
    stop: '20000'
    value: '20000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: ar
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.001'
    type: float
  states: {}
- name: blocks_rms_xx_0_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.001'
    type: float
  states: {}
- name: blocks_rms_xx_0_1_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.001'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\edson\Downloads\audio.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 0.68395, 0.21728
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 0.68395, 0.21728
    type: fff
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 0.68395, 0.21728
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fc
    decim: '1'
    gain: '0.8'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 0.1*fc
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fc
    decim: '1'
    gain: '1.1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 0.1*fc
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: fc
    decim: '1'
    gain: '1.1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 0.1*fc
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,4,1,2
    label1: Sinal de entrada
    label2: Sinal filtrado
    name: Sinal Ruidoso
    nconnections: '2'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    label1: Sinal de entrada
    label2: Sinal filtrado
    name: Sinal Ruidoso
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 0,4,1,2
    label1: Antes do filtro
    label2: Apos o filtro
    name: SNR dos sinais em funcao do tempo
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: SNR (dB)
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_rms_xx_0_1, '0']
- [analog_noise_source_x_0, '0', low_pass_filter_0_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_nlog10_ff_0_1_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_nlog10_ff_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_nlog10_ff_0_1, '0', blocks_sub_xx_0, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_rms_xx_0_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_rms_xx_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_rms_xx_0_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_rms_xx_0_1_0, '0', blocks_multiply_xx_0_2, '0']
- [blocks_rms_xx_0_1_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_rms_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0_1, '0']
- [fir_filter_xxx_0, '0', audio_sink_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_rms_xx_0_1_0, '0']
- [fir_filter_xxx_0_1, '0', blocks_rms_xx_0_0, '0']
- [low_pass_filter_0, '0', fir_filter_xxx_0, '0']
- [low_pass_filter_0_0, '0', fir_filter_xxx_0_0, '0']
- [low_pass_filter_0_1, '0', fir_filter_xxx_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

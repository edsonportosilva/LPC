options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Labo3_4
    output_language: python
    title: Receptor AM super-heterodino
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Amp.  Portadora
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fi
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: portadora
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Freq. Portadora
    outputmsgname: value
    showports: 'False'
    start: 75e3
    step: 25e3
    stop: 150e3
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: sintonia
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Sintonia
    outputmsgname: value
    showports: 'False'
    start: 50e3
    step: '1000'
    stop: 150e3
    value: 100e3
  states: {}
- name: Amplitude_Portadora
  id: analog_const_source_x
  parameters:
    const: amplitude
    type: float
  states: {}
- name: Portadora
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: portadora
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '0.05'
    type: float
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '0.05'
    type: float
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 10e3
    audio_stop: '10500'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: Realtek  Audio
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: fi+10e3
    low_cutoff_freq: fi-10e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\edson.DESKTOP-54IJM4F\Documents\GitHub\LPC\Aula 3\Labo3-4_fs44100.wav
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '600'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_RECTANGULAR
  states: {}
- name: oscilador_local
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sintonia+fi
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: 2**13
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: FI
    label2: Desmodulado
    name: Espectro de FI e Desmodulado
    nconnections: '2'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_5
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: 2**13
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Modulante
    label2: Modulado
    name: Espectro do Sinal Modulante e Modulado
    nconnections: '2'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Entrada
    label2: Modulado
    name: '"Sinais de Voz de Entrada e Modulado"'
    nconnections: '2'
    size: 1024*2
    srate: samp_rate
    type: float
  states: {}

connections:
- [Amplitude_Portadora, '0', blocks_add_xx_0, '1']
- [Portadora, '0', blocks_throttle_0, '0']
- [analog_agc_xx_0, '0', blocks_add_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_5, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_agc_xx_0_0, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0, '0', dc_blocker_xx_0_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_3, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_5, '1']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0_0, '0', analog_agc_xx_0_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_freq_sink_x_3, '1']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [oscilador_local, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

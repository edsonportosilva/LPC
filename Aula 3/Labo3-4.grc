<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Labo3_4</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receptor AM super-heterodino</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Amp.  Portadora</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fi</value></param>
<param><key>value</key><value>25e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>portadora</value></param>
<param><key>value</key><value>100e3</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Freq. Portadora</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>75e3</value></param>
<param><key>step</key><value>25e3</value></param>
<param><key>stop</key><value>150e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sintonia</value></param>
<param><key>value</key><value>100e3</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Sintonia</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50e3</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>150e3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>Amplitude_Portadora</value></param>
<param><key>const</key><value>amplitude</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>Portadora</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>portadora</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-3</value></param>
<param><key>reference</key><value>0.05</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-3</value></param>
<param><key>reference</key><value>0.05</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>10e3</value></param>
<param><key>audio_stop</key><value>10500</value></param>
<param><key>chan_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>fi+10e3</value></param>
<param><key>low_cutoff_freq</key><value>fi-10e3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>C:\Users\edson\Google Drive\Experimentos GRC\Aula 3\Labo3-4_fs44100.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>length</key><value>600</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>oscilador_local</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>sintonia+fi</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_3</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2**13</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>FI</value></param>
<param><key>label2</key><value>Desmodulado</value></param>
<param><key>name</key><value>Espectro de FI e Desmodulado</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_5</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2**13</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Modulante</value></param>
<param><key>label2</key><value>Modulado</value></param>
<param><key>name</key><value>Espectro do Sinal Modulante e Modulado</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Entrada</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Modulado</value></param>
<param><key>name</key><value>"Sinais de Voz de Entrada e Modulado"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>Amplitude_Portadora</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>Portadora</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_5</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>analog_agc_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>oscilador_local</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
